<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\103_i2C.ewp</path>
  </project>
  <batchBuild />
</workspace>
